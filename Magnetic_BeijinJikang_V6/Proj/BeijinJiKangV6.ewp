# IAR project BeijinJiKangV6.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F072C8 ST STM32F072C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F072; USE_IDWDG; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\App\inc; ..\User\inc; ..\CMSIS\inc; ..\Modbus\inc; ..\STM32F0xx_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BeijinJiKangV6.srec
  ILINK.IlinkOutputFile: BeijinJiKangV6.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32F072; USE_IDWDG; IAP_REMAP_INT; USE_STDPERIPH_DRIVER
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: BeijinJiKangV6.bin
  ILINK.IlinkIcfFile: BeijinJiKangV6.icf
  group App
    ../App/Src/: Analog.c Display.c main.c TDC_GP21.c UserApp.c
  group CMSIS
    ../CMSIS/Src/: startup_stm32f072.s system_stm32f0xx.c
  group Modbus
    ../Modbus/src/: STM32FXModbus.c
  group STM32F0xx_StdPeriph_Driver
    ../STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group User
    ../User/Src/: CommonFunctions.c flash_if.c FlashOperator.c SPI1.c STM32FX_Systick.c
